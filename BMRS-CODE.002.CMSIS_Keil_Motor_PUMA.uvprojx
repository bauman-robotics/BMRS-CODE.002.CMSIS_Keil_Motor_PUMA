# Keil uVision project BMRS-CODE.002.CMSIS_Keil_Motor_PUMA.uvprojx, settings and files
target BMRS-CODE.002.HAL_Keil_Motor_PUMA (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BMRS-CODE.002.CMSIS_Keil_Motor_PUMA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
